# Keil uVision project ESP01_USART_Bridge.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ESP01_USART_Bridge
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c my_clock.c my_clock.h my_dma.c my_dma.h my_esp01.c my_esp01.h my_gpio.c my_gpio.h my_timer.c my_timer.h my_usart.c my_usart.h webpages.h server.c server.h board_control.c board_control.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
