# Keil uVision project playing+Target_1.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: playing.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-packed -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality -Wno-packed -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality
  c include: ..\practice1;;
  memory RVCT4: RAM 0x8000000 size 0x10000
  memory RVCT9: ROM 0x20000000 size 0x5000
  scatter file: playing_Target_1.sct
  link misc: --load_addr_map_info --summary_stderr --info summarysizes
  group Source Group 1
    ./: main.c my_gpio.c my_gpio.h my_systick.c my_systick.h my_i2c.h my_i2c.c my_clock.h my_clock.c my_dma.h my_dma.c my_adc.h my_adc.c my_timer.h my_timer.c my_usart.c my_usart.h my_spi.h my_spi.c st7735.h st7735.c fonts.c fonts.h images.h COD.h fifa.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
